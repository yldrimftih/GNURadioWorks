options:
  parameters:
    author: neo
    generate_options: qt_gui
    id: virtual_NBFMTx_Virtual
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: if_rate
  id: variable
  parameters:
    value: int(usrp_rate/3)
  states: {}
- name: pl_freq
  id: variable_qtgui_chooser
  parameters:
    label: PL Tone
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 576e3
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Audio Gain
    start: '0'
    step: '0.1'
    stop: '100'
    value: '5'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: if_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '5000'
    interp: '1'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(usrp_rate/if_rate)
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/neo/Downloads/BabyElephantWalk60.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    gain: '1'
    interp: '1'
    samp_rate: if_rate
    type: interp_fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: if_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tag1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tag1
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP Sample Rate 576kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_nbfm_tx_0, '0', qtgui_sink_x_0, '0']
- [analog_nbfm_tx_0, '0', virtual_sink_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', band_pass_filter_0, '0']
- [blocks_add_xx_0_0, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_repeat_0, '0', zeromq_pub_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']
- [low_pass_filter_0, '0', blocks_repeat_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
